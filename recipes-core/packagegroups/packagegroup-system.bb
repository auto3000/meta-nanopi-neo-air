DESCRIPTION = "Communication package, WiFi, BT, etc"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = "\
    bash \
    vim \
    "
