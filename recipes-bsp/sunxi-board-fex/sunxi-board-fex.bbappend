COMPATIBLE_MACHINE = "(sun4i|sun5i|sun7i|sun8i|nanopi-neo|nanopi-neo-air)"

SRC_URI = "git://github.com/lcrb/sunxi-boards.git;protocol=git"
SRCREV = "86d5fac10fe9548a5d036edd7f87af95c90e2ed8"

